## sdkconfig.defaults
```kconfig
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_FREERTOS_USE_TRACE_FACILITY=y
CONFIG_MQTT_PROTOCOL_311=y
```
